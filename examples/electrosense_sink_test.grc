options:
  parameters:
    author: Sreeraj Rajendran
    category: Custom
    description: Electrosense sensor code
    generate_options: qt_gui
    id: electrosense_sink_test
    output_language: python
    title: Electosense
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: fc_slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 52e6
    step: 500e3
    stop: 1.8e9
    value: 100e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: g_slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: ppm_slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-150'
    step: '1'
    stop: '150'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensorid
  id: variable
  parameters:
    value: '123456'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: electrosense_sensor_sink_0
  id: electrosense_sensor_sink
  parameters:
    avgfactor: int(3/alpha)
    avrofile: /home/rsreeraj/gnu_work/gr-electrosense/python/rtl-spec.avsc
    certfile: Sensor-SSL-Cert.pem
    dtype: float
    fftsize: fft_size
    freq: int(fc_slider)
    freqoverlap: '0.1'
    freqresol: int(samp_rate/fft_size)
    gain: g_slider
    hopping: '0'
    keyfile: Sensor-SSL-SK.pem
    port: '5000'
    senid: sensorid
    server: 127.0.0.1
    veclen: fft_size
    window: '2'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: ppm_slider
    dc_offset_mode0: '2'
    freq0: fc_slider
    gain0: g_slider
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    type: fc32
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha
    type: float
    vlen: fft_size
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', electrosense_sensor_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
