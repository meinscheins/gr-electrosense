options:
  parameters:
    author: Sreeraj Rajendran
    category: Custom
    description: Electrosense sensor code
    generate_options: qt_gui
    id: electrosense_hopping
    output_language: python
    title: Electosense
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: cfreq
  id: variable
  parameters:
    value: scanning.step(start_f,end_f,samp_rate/1.5,prober,hop_mode,0.8,0.8)
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: hop_mode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: navg_vectors
  id: variable
  parameters:
    value: '100'
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: prober
  id: variable_function_probe
  parameters:
    block_id: vecprobe
    function_name: level
    poll_rate: 1/(tune_delay+(1/samp_rate*fft_size*navg_vectors))
    value: '1'
  states: {}
- name: rfgain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensorid
  id: variable
  parameters:
    value: '123456'
  states: {}
- name: tune_delay
  id: variable
  parameters:
    value: '50e-3'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: navg_vectors
    type: float
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: electrosense_discard_samples_0
  id: electrosense_discard_samples
  parameters:
    mode: varchange
    nsamples: int(tune_delay * samp_rate)
    tag_name: pmt.intern("burst_len")
    var: int(cfreq)
  states: {}
- name: end_f
  id: parameter
  parameters:
    label: End Frequency
    type: eng_float
    value: 500e6
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    showports: 'True'
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: 250e3
    corr0: ppm
    dc_offset_mode0: '2'
    freq0: cfreq
    gain0: rfgain
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    type: fc32
  states: {}
- name: scanning
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\ncur=-1.0\nfft_arr={}\nsim_arr={}\nsim_red = 1.05\n\nimport numpy as np\nimport random\n\ndef crosscorr(x,y):\n    a = np.correlate(x, y, mode='full')\n    norm = np.sqrt(np.power(x,2).sum()) *  np.sqrt(np.power(y,2).sum())\n    #a = (a - np.mean(a)) / (np.std(a) * len(a))\n    #return np.nan_to_num(a)\n    return np.nan_to_num(a/norm)\n\ndef sim2prob(x):\n    return np.exp(x)/np.exp(x).sum()\n\ndef upd_sim_arr():\n    vals = np.array(sim_arr.values())\n    keys = np.array(sim_arr.keys())\n    prob = sim2prob(vals)\n    prob = prob >= np.random.rand()\n    vals[prob]=vals[prob]/sim_red\n    for i in range(len(keys)):\n        sim_arr[keys[i]] = vals[i]\n    return min(sim_arr, key=sim_arr.get)\n\ndef step(start,end,incr,val,mode,wt,alpha_s):\n    global cur\n    global fft_arr, sim_arr\n\n    #sequential scanning\n    if mode==0:\n        cur=cur+incr\n    #random scanning\n    elif mode == 1:\n        rval = int(((end-start)/incr)+0.5)\n        cur=cur+incr*random.randint(1,rval)\n    #similarity scanning\n    else:\n        if(fft_arr.has_key(cur)):\n            cc = crosscorr(fft_arr[cur],val)\n            delf = cc.max()\n            r = np.argmax(cc)\n            #print r, wt, delf\n            sim  = r * wt + (1-wt) * delf\n            if(sim_arr.has_key(cur)):\n                pass\n            else:\n                sim_arr[cur]=0\n            sim_arr[cur] = alpha_s * sim + sim_arr[cur] * (1-alpha_s)\n            new=upd_sim_arr()\n            #print \"new:\",new\n            #print \"sim:\",sim_arr\n        else:\n            if(cur>0):\n                sim_arr[cur]=0\n            new=cur+incr\n        fft_arr[cur]= val\n        cur=new\n\n    if (cur > end or cur < start):\n        cur = start\n    print cur\n    return cur\n\n"
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha
    type: float
    vlen: fft_size
  states: {}
- name: start_f
  id: parameter
  parameters:
    label: Start frequency
    type: eng_float
    value: 50e6
  states: {}
- name: vecprobe
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: fft_size
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', vecprobe, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [electrosense_discard_samples_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', electrosense_discard_samples_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
