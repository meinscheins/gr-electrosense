options:
  parameters:
    author: Sreeraj Rajendran
    category: Custom
    description: Electrosense sensor code
    generate_options: qt_gui
    id: electrosense_mqtt_test
    output_language: python
    title: Electosense
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: cfreq
  id: variable
  parameters:
    value: scanning.step(start_f,end_f,samp_rate/1.5,prober,hop_mode,0.8,0.8)
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: hop_mode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: navg_vectors
  id: variable
  parameters:
    value: '100'
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: prober
  id: variable_function_probe
  parameters:
    block_id: vecprobe
    function_name: level
    poll_rate: 1/(tune_delay+(1/samp_rate*fft_size*navg_vectors))
    value: '1'
  states: {}
- name: rfgain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensorid
  id: variable
  parameters:
    value: '123456'
  states: {}
- name: tune_delay
  id: variable
  parameters:
    value: '50e-3'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: navg_vectors
    type: float
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: electrosense_discard_samples_0
  id: electrosense_discard_samples
  parameters:
    mode: varchange
    nsamples: int(tune_delay * samp_rate)
    tag_name: pmt.intern("burst_len")
    var: int(cfreq)
  states: {}
- name: electrosense_mqtt_client_0
  id: electrosense_mqtt_client
  parameters:
    ca_cert: ''
    certfile: ''
    channel: electrosense
    keyfile: ''
    port: '1883'
    server: 127.0.0.1
  states: {}
- name: electrosense_variable_updater_0
  id: electrosense_variable_updater
  parameters: {}
  states: {}
- name: end_f
  id: parameter
  parameters:
    label: End Frequency
    type: eng_float
    value: 500e6
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    showports: 'True'
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: scanning
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      cur=-1.0
      fft_arr={}
      sim_arr={}
      sim_red = 1.05

      import numpy as np
      import random

      def crosscorr(x,y):
          a = np.correlate(x, y, mode='full')
          norm = np.sqrt(np.power(x,2).sum()) *  np.sqrt(np.power(y,2).sum())
          #a = (a - np.mean(a)) / (np.std(a) * len(a))
          #return np.nan_to_num(a)
          return np.nan_to_num(a/norm)

      def sim2prob(x):
          return np.exp(x)/np.exp(x).sum()

      def upd_sim_arr():
          vals = np.array(sim_arr.values())
          keys = np.array(sim_arr.keys())
          prob = sim2prob(vals)
          prob = prob >= np.random.rand()
          vals[prob]=vals[prob]/sim_red
          for i in range(len(keys)):
              sim_arr[keys[i]] = vals[i]
          return min(sim_arr, key=sim_arr.get)

      def step(start,end,incr,val,mode,wt,alpha_s):
          global cur
          global fft_arr, sim_arr

          #sequential scanning
          if mode==0:
              cur=cur+incr
          #random scanning
          elif mode == 1:
              rval = int(((end-start)/incr)+0.5)
              cur=cur+incr*random.randint(1,rval)
          #similarity scanning
          else:
              if fft_arr:
                  if(fft_arr.has_key(cur)):
                      cc = crosscorr(fft_arr[cur],val)
                      delf = cc.max()
                      r = np.argmax(cc)
                      #print r, wt, delf
                      sim  = r * wt + (1-wt) * delf
                      if(sim_arr.has_key(cur)):
                          pass
                      else:
                          sim_arr[cur]=0
                          sim_arr[cur] = alpha_s * sim + sim_arr[cur] * (1-alpha_s)
                          new=upd_sim_arr()
                          #print "new:",new
                          #print "sim:",sim_arr
                  else:
                      if(cur>0):
                          sim_arr[cur]=0
                          new=cur+incr
              else:
                  if(cur>0):
                      sim_arr[cur]=0
                  new=cur+incr
              fft_arr[cur]= val
              cur=new

          if (cur > end or cur < start):
              cur = start
          #print cur
          return cur
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha
    type: float
    vlen: fft_size
  states: {}
- name: start_f
  id: parameter
  parameters:
    label: Start frequency
    type: eng_float
    value: 50e6
  states: {}
- name: vecprobe
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: fft_size
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', vecprobe, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', electrosense_discard_samples_0, '0']
- [electrosense_discard_samples_0, '0', blocks_stream_to_vector_0, '0']
- [electrosense_mqtt_client_0, out, electrosense_variable_updater_0, in]
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
